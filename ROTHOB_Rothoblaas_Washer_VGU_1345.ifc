Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: bfaac981-df82-465c-9fa8-2ec4df86710d, NumberOfSaves: 54], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Washer_VGU_1345.ifc
Time: 2025-10-01T16:55:52
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Collegamenti strutturali : ROTHOB_Rothoblaas_Washer_VGU_1345 : VGU1345_37x59x33mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Washer_VGU_1345; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/screws/screws-structures/vgu; Revision: 000; UniClass2015Code: Pr_20_29_60_96; UniClass2015Title: Washers; UniClass2015Version: Products v1.39; Version: 002
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_Electrogalvanized
Type - Quote - BaseHeigth_h: 4.3 mm; ExternalDiameter_D2: 27.4 mm; GlobalHeigth_H: 33 mm; InternalDiameter_D1: 14 mm; Length_L: 58.673 mm; SlottedHoleLength_Lf: 49.0 ÷ 50,0 mm; SlottedHoleWidth_Bf: 20.0 ÷ 21,0 mm; SteelPlateThickness_Splate: 5.0 ÷ 15,0 mm; Width_B: 36.716 mm
Type - Dati identità - Descrizione: 45° washer for VGS; Nome del tipo: VGU1345_37x59x33mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_29_60_96: Washers; CECode: ETA-11/0030; CETitle: Rotho Blaas Self-tapping screws and threaded rods; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; DurationUnit: Years; ExpectedLife: 50; Features: Washers for self-tapping screw; Finish: Electrogalvanized; Grade: n/a; GTIN: 8053800078801; ICC-ESCode: AC233 ESR-4645 / ELC-4645; ICC-ESTitle: Rotho Blaas Self-tapping Wood Screws / Rotho Blaas Self-tapping Wood Screws; Material: Electrogalvanized Carbon Steel; MinWeight: 0.212 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: VGU1345; ModelReference: n/a; Name: Washer; Nome famiglia: ROTHOB_Rothoblaas_Washer_VGU_1345; NominalHeight: 33 mm; NominalLength: 58.673 mm; NominalScrewDiameter: 13 mm; NominalWidth: 36.716 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 37x59x33 mm; SustainabilityPerformance: BVB Accepted / Sundahus A; UKCACode: UKTA-0836 22/6195; UKCATitle: Rotho Blaas Self-tapping screws and threaded rods; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Washer; Category: Pr_20_29_60_96: Washers
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: VGU1345_37x59x33mm; sets with these values: 2
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.00429183 m2; Volume: 0.0000280431 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Washer_VGU_1345; Famiglia e tipo: ROTHOB_Rothoblaas_Washer_VGU_1345: VGU1345_37x59x33mm; ID tipo: 550837; Tipo: VGU1345_37x59x33mm
